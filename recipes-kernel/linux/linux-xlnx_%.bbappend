# To enable this recipe, set PREFERRED_PROVIDER_virtual/kernel = "linux-xlnx"

LINUX_VERSION_EXTENSION ?= "-ebaz4205"

include linux-xlnx-ebaz4205.inc
