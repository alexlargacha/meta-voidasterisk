SUMMARY = "ebaz4205 image"
DESCRIPTION = "Contents all need packages to deploy a rootfs for the EBAZ4205 Board"

LICENSE = "MIT"

inherit ebaz4205-image
